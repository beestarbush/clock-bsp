FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://asound.conf"